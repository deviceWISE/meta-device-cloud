inherit setuptools3
require python3-paho-mqtt.inc

