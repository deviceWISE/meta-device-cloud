# Copyright (C) 2017 Wind River Systems, Inc.
# License: MIT
#
inherit setuptools
require python-paho-mqtt.inc

