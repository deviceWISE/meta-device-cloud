#
# Copyright (C) 2017 Wind River Systems, Inc.
#
export BUILD_SYS
export HOST_SYS

