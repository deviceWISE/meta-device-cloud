# this fixes a provides collision with other packages inheriting python-setuptools.
RDEPENDS_${PN} = "python-modules python-setuptools"

